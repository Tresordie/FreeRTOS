# Keil uVision project usb_dev_v3.uvprojx, settings and files
target chapter16_1_freertos_SemaphoreBinary (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb_dev_v3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,
  c include: ..\library\CMSIS;..\library\STM32F10x_StdPeriph_Driver\inc;..\user\bsp;..\user\bsp\inc;..\user\app\inc;..\freertos\include;..\freertos\port\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../library/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../library/CMSIS/: core_cm3.c system_stm32f10x.c
  group stdlib
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../user/bsp/: bsp.c
    ../user/bsp/src/: bsp_gpio.c bsp_nvic.c bsp_sw_delay.c bsp_i2c_hw.c bsp_spi_flash.c bsp_sdio_sdcard.c bsp_exti.c bsp_spi_tftlcd.c bsp_key.c
  group freertos/port
    ../freertos/port/MemMang/: heap_4.c
    ../freertos/port/RVDS/ARM_CM3/: port.c
  group freertos/src
    ../freertos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group app
    ../user/app/src/: main.c
    ../user/bsp/: stm32f10x_it.c
    ../user/app/inc/: FreeRTOSConfig.h
